# Keil uVision project t1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: t1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\applications\keli 5 C51\C51\INC\Atmel
  asm include: D:\applications\keli 5 C51\C51\INC\Atmel
  group Source Group 1
    ./: main.c
